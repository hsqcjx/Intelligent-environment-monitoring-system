# Keil uVision project MDK.uvprojx, settings and files
target STM32F103ZE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MDK +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD
  c include: .\SYSLIB;.\SYS;.\SYSTEM\LED;.\SYSTEM\DELAY;.\SYSTEM\KEY;.\SYSTEM\USART;.\SYSTEM\OLED;.\SYSTEM\EXTI;.\SYSTEM\TIMER;.\SYSTEM\FONT;.\SYSTEM\GT9147_TOUCH;.\UCOSII\CONFIG;.\UCOSII\CORE;.\UCOSII\PORT;.\SYSTEM\NT35510;.\SYSTEM\OLED;.\SYSTEM\ADC;.\SYSTEM\DHT11
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./USER/: main.c
  group SYSLIB
    ./SYSLIB/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group SYSTEM
    ./SYS/: sys.c
    ./SYSTEM/LED/: led.c
    ./SYSTEM/DELAY/: delay.c
    ./SYSTEM/USART/: usart.c
    ./SYSTEM/EXTI/: exti.c
    ./SYSTEM/TIMER/: timer.c
    ./SYSTEM/NT35510/: nt35310_lcd.c
    ./SYSTEM/ADC/: adc.c
    ./SYSTEM/DHT11/: DHT11.c
    ./SYSTEM/FONT/: Temp.c hum.c Gas.c dust.c
  group FONT
    ./SYSTEM/FONT/: font.c
  group UCOSII-CORE
    ./UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ./UCOSII/PORT/: os_cpu_a.asm os_cpu_c.c os_cpu.h
  group UCOSII-CONFIG
    ./UCOSII/CONFIG/: includes.h os_cfg.h
